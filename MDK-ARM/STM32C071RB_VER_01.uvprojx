# Keil uVision project STM32C071RB_VER_01.uvprojx, settings and files
target STM32C071RB_VER_01 (6230000::V6.23::ARMCLANG)
  device: STM32C071RBTx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32C071RB_VER_01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C071xx
  c include: ../Core/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include;..\Core\Inc\Application\Handle;..\Core\Inc\Application;..\Core\Inc\Drivers;..\Core\Inc\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ./: startup_stm32c071xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c i2c.c rtc.c tim.c usart.c usb.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_adc.c stm32c0xx_hal_adc_ex.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_cortex.c stm32c0xx_hal_exti.c stm32c0xx_hal_crc.c stm32c0xx_hal_crc_ex.c stm32c0xx_hal_i2c.c stm32c0xx_hal_i2c_ex.c stm32c0xx_hal_rtc.c stm32c0xx_hal_rtc_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c stm32c0xx_hal_pcd.c stm32c0xx_hal_pcd_ex.c stm32c0xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
  group App
    ../Core/Src/Application/: app_manager.c cli_driver.c controller.c relato.c retarget.c
  group Modules
    ../Core/Src/Modules/: gerenciador_configuracoes.c GXXX_Equacoes.c scale_filter.c servo_controle.c
  group Drivers_Custom
    ../Core/Src/Drivers/: ads1232_driver.c dwin_driver.c eeprom_driver.c pcb_frequency.c pwm_servo_driver.c rtc_driver.c temp_sensor.c
  group App/Handle
    ../Core/Src/Application/Handle/: autenticacao_handler.c display_handler.c dwin_parser.c graos_handler.c medicao_handler.c rtc_handler.c
software components: CMSIS:CORE 5.6.0
